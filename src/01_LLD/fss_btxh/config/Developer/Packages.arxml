<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00049.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="C7EBDC86-AF16-47E6-AB2D-27D7AF643CE4">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="46323AC6-6FD7-4B1C-8B51-2E1EBA8EEB12">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ADD9FD92-4770-40F0-B8C1-7F375D035EBF">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F8F071CB-949F-4527-83E3-47458C373B0E">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CAAF9A43-E3B1-43BF-96B2-6872841CF4E7">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D60D8CCD-215B-4348-8C48-6CEBB7BE22E9">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4C6B8A82-D8E9-46B0-A33D-1E40D9DB3631">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DA74C980-CC5E-4807-BA94-55930672B978">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9D195FD8-6C5F-406C-9DF0-78EB0BDA3357">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2C761FBE-B6D9-4F5A-83B3-08E8B8D86DCE">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="644A54B1-76B1-4203-943F-2C1146FB65EA">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A74DCECB-F8B7-4C62-BDBA-CFAFC9891086">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="906B096B-F77A-4D4D-B66B-2CA13FBFE9A1">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E749A425-F013-4290-9795-C0EFC16DDB3F">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4772BA1E-051E-4F8E-B272-B398A9A03540">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6DDB4917-45A5-4628-A727-82EBB1933BDB">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EBC6B416-48E9-428C-9E00-567B7D0FE2AE">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B8EABEC8-D6DF-48BE-9F49-501810CFD0A2">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D50E3355-F475-4935-B9B6-3DEDEC052BFD">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="224B578C-A32F-48D3-8ED5-45D09170BC73">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3F4B7A68-EA0E-429B-91C7-4691FB28A29A">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BFD9D7C-75A7-44E9-8478-2B34B72DFD8D">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6F4FAF16-FC20-46BC-868A-A4BB7D630022">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2F0C92E8-A8D5-458D-A1BF-308AAB34C630">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1DC2D2DE-D7C9-46F8-8A48-219A84290810">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A59B0EBE-1993-4101-AB65-DE110AE21B31">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3E4803F9-5A70-4636-9BC8-3C9B6A03B3E1">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7B4AAB04-9D7C-48CF-AF9F-E1B6368FA380">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FE7F3A21-CBCA-49F3-B473-FE1BFCBD905E">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5553D753-82C7-4245-8716-9C66EBE6F713">
      <SHORT-NAME>MICROSAR_MemMap</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8F1C92BC-30D2-4223-B5C7-BEC7E9B308B1">
          <SHORT-NAME>SwAddrMethods</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>